# IAR project Basic_rtos2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\Users\ray\Desktop\STM\stsw-stm32068\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include; C:\Users\ray\Desktop\STM\stsw-stm32068\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include; C:\Users\ray\Desktop\STM\stsw-stm32068\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; C:\Users\ray\Desktop\STM\stsw-stm32068\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery; C:\Users\ray\Desktop\STM\Basic_rtos2; C:\Users\ray\Desktop\STM\FreeRTOSV8.2.3\FreeRTOS\Source\include; C:\Users\ray\Desktop\STM\FreeRTOSV8.2.3\FreeRTOS\Demo\Common\include; C:\Users\ray\Desktop\STM\FreeRTOSV8.2.3\FreeRTOS\Source\portable\IAR\ARM_CM4F; C:\Users\ray\Desktop\STM\stsw-stm32068\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32_USB_Device_Library\Core\inc; C:\Users\ray\Desktop\STM\stsw-stm32068\STM32F4-Discovery_FW_V1.1.0\my_library; C:\Users\ray\Desktop\STM\Basic_rtos2\Trace_Recorder_Configuration; C:\Users\ray\Desktop\STM\Basic_rtos2\Trace_Recorder_Configuration; C:\Users\ray\Desktop\STM\FreeRTOSV8.2.3\FreeRTOS-Plus\Source\FreeRTOS-Plus-Trace\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Users\ray\Desktop\STM\Basic_rtos2
  OBJCOPY.OOCOutputFile: Basic_rtos2.srec
  ILINK.IlinkOutputFile: Basic_rtos2.out
  ILINK.IlinkIcfFile: Basic_rtos2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../FreeRTOSV8.2.3/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./: main.c system_stm32f4xx.c
    ../stsw-stm32068/STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery.h
    ../FreeRTOSV8.2.3/FreeRTOS-Plus/Source/FreeRTOS-Plus-Trace/: trcRecorderFreeRTOS.c
  group CMSIS
    ../stsw-stm32068/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group My_library
    ../stsw-stm32068/STM32F4-Discovery_FW_V1.1.0/my_library/: usart_print.c usart_print.h
  group RTOS_Portable
    ../FreeRTOSV8.2.3/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group RTOS_Source
    ../FreeRTOSV8.2.3/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group ST
    ../stsw-stm32068/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM_STD_LIBRARY
    ../stsw-stm32068/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
